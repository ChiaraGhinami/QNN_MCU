# Keil uVision project M55_TFLite.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: SSE-300-MPS3 ARM
  pack: ARM.V2M_MPS3_SSE_300_BSP.1.3.0
  cpu: IRAM(0x00000000,0x00080000) IRAM2(0x01000000,0x00100000) XRAM(0x20000000,0x00020000) XRAM2(0x20020000,0x00020000) XRAM3(0x20040000,0x00020000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: M55_TFLite
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=1
  memory RVCT6: RAM 0x20000000 size 0x20000
  memory RVCT7: RAM 0x20020000 size 0x20000
  memory RVCT8: RAM 0x20040000 size 0x20000
  memory RVCT9: RAM 0x0 size 0x80000
  memory RVCT10: RAM 0x1000000 size 0x100000
  scatter file: .\RTE\Device\SSE-300-MPS3\fvp_sse300_mps3_s.sct
  group Source Group 1
    ./: main.cpp arm_nn_softmax_common_s8.c main.h FFNN_model.cpp FFNN_model.h parameters.h
software components: CMSIS:CORE 5.6.0, CMSIS:DSP 1.14.1, CMSIS:NN Lib 3.1.0, Device:Definition 1.2.0, Device:Startup 1.2.0, Native Driver:SysCounter 1.1.0, Native Driver:SysTimer 1.1.0, Native Driver:Timeout 1.0.0, Data Exchange:Serialization:flatbuffers 1.22.8, Data Processing:Math:gemmlowp fixed-point 1.22.8, Data Processing:Math:kissfft 1.22.8, Data Processing:Math:ruy 1.22.8, Machine Learning:TensorFlow:Kernel Utils 1.22.8, Machine Learning:TensorFlow:Kernel 1.22.8, Machine Learning:TensorFlow:Testing 1.22.8
